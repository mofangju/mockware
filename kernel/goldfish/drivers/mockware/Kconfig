## kernel/goldfish/drivers/mockware/Kconfig
```kconfig
config MOCKWARE
	tristate "Mockware Linux Driver"
	default n
	---help---
		This is the mockware driver for demo.
```
